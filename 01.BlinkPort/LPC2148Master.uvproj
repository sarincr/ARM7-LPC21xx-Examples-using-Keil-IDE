# Keil uVision project LPC2148Master.uvproj, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC2148 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: LPC2148Master +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\lib\adc;.\lib\delay;.\lib\gpio;.\lib\irq;.\lib\nstring;.\lib\serial;.\lib\system;.\modules\gsm;.\modules\lcd;.\modules\dht11;.\modules\hcsr04;.\lib\i2c;.\lib\spi;.\modules\mcp320x;.\lib\rtc;.\modules\ssd1306;.\modules\keypad;.\lib\extint;.\modules\nrf24;.\modules\mpu6050
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    ./: Startup.s
  group lib
    ./lib/adc/: adc.c
    ./lib/delay/: delay.c
    ./lib/gpio/: gpio.c
    ./lib/irq/: irq.c
    ./lib/nstring/: Nstring.c
    ./lib/serial/: serial.c
    ./lib/i2c/: i2c.c
    ./lib/spi/: spi.c
    ./lib/rtc/: rtc.c
    ./lib/extint/: extint.c
  group Main
    ./: main.c
